<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>heart_beat</key>
<param><key>id</key><value>heart_beat_0</value></param>
<param><key>period</key><value>1</value></param>
<param><key>key</key><value>key</value></param>
<param><key>value</key><value>value1</value></param>
</block>
<block>
<key>virtual_channel_mux</key>
<param><key>id</key><value>virtual_channel_mux_0</value></param>
<param><key>port_count</key><value>4</value></param>
</block>
<block>
<key>virtual_channel_demux</key>
<param><key>id</key><value>virtual_channel_demux_0</value></param>
<param><key>port_count</key><value>3</value></param>
</block>
<block>
<key>precog_msg_to_stdout</key>
<param><key>id</key><value>precog_msg_to_stdout_0</value></param>
</block>
<block>
<key>options</key>
<param><key>id</key><value>mux_work</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<connection><source_block_id>virtual_channel_mux_0</source_block_id><sink_block_id>virtual_channel_demux_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>heart_beat_0</source_block_id><sink_block_id>virtual_channel_mux_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_channel_demux_0</source_block_id><sink_block_id>precog_msg_to_stdout_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
