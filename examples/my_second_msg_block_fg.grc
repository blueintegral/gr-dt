<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>my_second_msg_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>heart_beat</key>
<param><key>id</key><value>heart_beat_0</value></param>
<param><key>period</key><value>1</value></param>
<param><key>key</key><value>hello</value></param>
<param><key>value</key><value>world</value></param>
</block>
<block>
<key>precog_msg_to_stdout</key>
<param><key>id</key><value>precog_msg_to_stdout_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
</block>
<block>
<key>extras_pmt_rpc</key>
<param><key>id</key><value>extras_pmt_rpc_0</value></param>
<param><key>result_msg</key><value>False</value></param>
</block>
<block>
<key>heart_beat</key>
<param><key>id</key><value>heart_beat_0_0</value></param>
<param><key>period</key><value>5</value></param>
<param><key>key</key><value>hello</value></param>
<param><key>value</key><value>world</value></param>
</block>
<block>
<key>gr_null_sink</key>
<param><key>id</key><value>gr_null_sink_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>precog_msg_to_stdout</key>
<param><key>id</key><value>precog_msg_to_stdout_0</value></param>
<param><key>_enabled</key><value>False</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>None</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>usrp_source</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>105e6</value></param>
<param><key>gain0</key><value>15</value></param>
<param><key>ant0</key><value>RX2</value></param>
</block>
<block>
<key>my_second_msg_block</key>
<param><key>id</key><value>my_second_msg_block_0</value></param>
<param><key>freqlist</key><value>95e6,605e6,915e6,880e6,1986e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>25e6</value></param>
</block>
<connection><source_block_id>heart_beat_0</source_block_id><sink_block_id>my_second_msg_block_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>heart_beat_0_0</source_block_id><sink_block_id>my_second_msg_block_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>my_second_msg_block_0</source_block_id><sink_block_id>precog_msg_to_stdout_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>my_second_msg_block_0</source_block_id><sink_block_id>extras_pmt_rpc_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>extras_pmt_rpc_0</source_block_id><sink_block_id>precog_msg_to_stdout_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>usrp_source</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>my_second_msg_block_0</source_block_id><sink_block_id>gr_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
