<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>my_first_msg_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>precog_msg_to_stdout</key>
<param><key>id</key><value>precog_msg_to_stdout_0</value></param>
</block>
<block>
<key>heart_beat</key>
<param><key>id</key><value>heart_beat_0</value></param>
<param><key>period</key><value>1</value></param>
<param><key>key</key><value>hello</value></param>
<param><key>value</key><value>world</value></param>
</block>
<block>
<key>heart_beat</key>
<param><key>id</key><value>heart_beat_0_0</value></param>
<param><key>period</key><value>1</value></param>
<param><key>key</key><value>hello</value></param>
<param><key>value</key><value>world</value></param>
</block>
<block>
<key>my_first_msg_block</key>
<param><key>id</key><value>my_first_msg_block_0</value></param>
</block>
<connection><source_block_id>heart_beat_0</source_block_id><sink_block_id>my_first_msg_block_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>my_first_msg_block_0</source_block_id><sink_block_id>precog_msg_to_stdout_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>heart_beat_0_0</source_block_id><sink_block_id>my_first_msg_block_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
</flow_graph>
